# Keil uVision project FS1022H.uvprojx, settings and files
target FS1022H (ARM-ADS)
  device: GD32F330C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FS1022H +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F330
  c include: ..\Code\Firmware;..\Code\Firmware\CMSIS;.\RTE\_GD32E230;..\Code;..\Code\Firmware\CMSIS\GD\GD32F3x0\Include;..\Code\Firmware\GD32F3x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group code
    ../Code/: buzzer.c flash_fmc.c history.c key.c led.c main.c protocol.c sample.c systick.c two_wire.c usart.c gd32f3x0_it.c system.c rtc.c sensor.c calibration.c relay.c
  group CMSIS
    ../Code/Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group CMSIS/Starttup
    ../Code/Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group peripherals
    ../Code/Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_spi.c
